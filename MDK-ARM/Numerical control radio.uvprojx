# Keil uVision project Numerical control radio.uvprojx, settings and files
target Numerical control radio (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Numerical control radio +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103x6
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../RDA5807M/H;../User/H;../Rotary_encoder/H;../smg_8bit_595/H;../IR_NEC/H
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group C
    ../RDA5807M/C/: RDA5807M.c
    ../User/C/: Print.c MY.c
    ../Rotary_encoder/C/: Rotary_Encoder.c
    ../smg_8bit_595/C/: TUBE.c
    ../IR_NEC/C/: IR_NEC.c
  group H
    ../RDA5807M/H/: RDA5807M.h
    ../User/H/: Print.h MY.h
    ../Rotary_encoder/H/: Rotary_Encoder.h
    ../smg_8bit_595/H/: TUBE.h
    ../IR_NEC/H/: IR_NEC.h
software components: CMSIS:CORE 4.3.0
